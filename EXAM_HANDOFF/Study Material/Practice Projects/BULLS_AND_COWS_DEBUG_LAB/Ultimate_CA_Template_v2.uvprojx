# Keil uVision project Ultimate_CA_Template_v2.uvprojx, settings and files
target CA Exam (6220000::V6.22::ARMCLANG)
  device: LPC1768 NXP
  pack: Keil.LPC1700_DFP.2.7.2
  cpu: IRAM(0x10000000,0x8000) IRAM2(0x2007C000,0x8000) IROM(0x00000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: CA_Exam
  c flags: Optim=2 v6Lang=1 v6LangP=3
  c include: .\Source;.\Source\platform;.\Source\exam;.\Source\CMSIS_core
  asm include: .\Source;.\Source\platform;.\Source\exam;.\Source\CMSIS_core
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group 00 - START HERE
    ./: READ_ME_FIRST.txt
    ./Documentation/: PERIPHERAL_RECIPES.md FIVE_MINUTE_CHECKLIST.md EXAM_WORKFLOW.md API_REFERENCE.md
  group 01 - WRITE YOUR ANSWER HERE
    ./Source/exam/: exam_user.c exam_asm.s
  group 90 - INTERNAL - DO NOT EDIT
    ./Source/exam/: exam_main.c
    ./Source/platform/: exam_api.c exam_board.c exam_compat.c exam_faults.c exam_config.h exam_api.h exam_compat.h
    ./Source/: system_LPC17xx.c startup_LPC17xx.s
